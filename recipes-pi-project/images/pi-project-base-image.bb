DESCRIPTION = "Basic project PI image"
LICENSE = "MIT"

inherit core-image
