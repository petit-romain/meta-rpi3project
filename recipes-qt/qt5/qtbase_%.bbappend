PACKAGECONFIG_append = " libinput fontconfig eglfs gles2"
PACKAGECONFIG_remove = " icu x11 opengl"

DEPENDS += " userland"